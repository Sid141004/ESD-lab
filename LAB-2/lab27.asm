	AREA RESET, DATA, READONLY;ADD 2 128 BIT NUMBERS
	EXPORT __Vectors
__Vectors
	DCD 0X10001001;STACK POINTER VALUE WHEN
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =N1;ARRAY
	LDR R6, =N2
	MOV R1, #4;FOR LOOP
	LDR R5, =DST;R2 FOR SUM AND R3 FOR CARRY
	
BACK LDR R4, [R0], #4
	LDR R7, [R6], #4
	ADCS R2,R4,R7
	STR R2, [R5], #4
	SUB R1, #1
	TEQ R1, #0
	BNE BACK
	ADC R8, #0
	STR R8, [R5]
STOP B STOP
N1 DCD 0XA1345678,0X13523809,0XA5,0XB456
N2 DCD 0X13523809,0XA1345678,0XB456,0XA5
	AREA mydata, DATA, READWRITE
DST DCD 0,0,0,0,0
	END
