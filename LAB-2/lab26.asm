	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001001;STACK POINTER VALUE WHEN
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =N;ARRAY
	MOV R1, #2;FOR LOOP
	LDR R5, =SUM;R2 FOR SUM AND R3 FOR CARRY
	
BACK LDR R4, [R0], #4
	ADDS R2,R4
	ADC R3,#0
	SUBS R1, #1
	BNE BACK
	
	STR R2, [R5], #4
	STR R3, [R5]
STOP B STOP
SUM DCD 0,0
N DCD 0XA1345678,0X13523809;0XA5,0XB456,0X1233,0X12F,0XE56,0X11,0X22,0X33
	AREA mydata, DATA, READWRITE
DST DCD 0,0
	END
