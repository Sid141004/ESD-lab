	AREA RESET, DATA, READONLY ;WRITE AN ASSEMBLY LEVEL CODE TO COPY 5 32 BIT NUMBERS[array] FROM CODE MEMOMERY T0 DATA MEMOMERY using loop
	EXPORT __Vectors
__Vectors
	DCD 0X10001001 ;STACK POINTER VALUE WHEN
	DCD Reset_Handler ;reset vector
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R3, #5
	LDR R0, =N;R0 = 0X000014?
	LDR R1, =DST
BACK LDR R2, [R0];R2=R0
	STR R2, [R1];OPPOSITE TO LDR
	LDR R2, [R0], #4
	STR R2, [R1], #4
	SUB R3, #1
	CMP R3, #0
	BNE BACK 
STOP B STOP
N DCD 0X12345678,0X6A,0X234,0X49C,0XA13BC
	AREA mydata, DATA, READWRITE
DST DCD 0,0
	END
