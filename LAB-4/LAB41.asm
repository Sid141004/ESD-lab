	AREA RESET, DATA, READONLY;2 DIGIT HEXA TO ASCII(NOT STORING IN DATA MEMORY)
	EXPORT __Vectors

__Vectors
	DCD 0X40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R0, #0XFE
	
	LSR R1,R0,#4
	AND R2,R0,#0XF
	
	CMP R1,#0XA
	BLO EXIT1
	ADD R1,#0X37
	B EXIT2
EXIT1 ADD R1,#0X30
	
EXIT2 CMP R2,#0XA
	BLO EXIT3
	ADD R2,#0X37
	B EXIT4
EXIT3 ADD R2,#0X30

EXIT4
STOP B STOP
	END
